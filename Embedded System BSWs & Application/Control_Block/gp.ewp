# IAR project gp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Common_Macros.h Compiler.h Control_ECU.c Control_ECU.h cstartup_M.c Det.c Det.h Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h external_eeprom.c external_eeprom.h external_eeprom_cfg.h gps.c gps.h gps_gsm_buffer.c gps_gsm_buffer.h GPT.c GPT.h gsm.c gsm.h gsm_cfg.h I2c.c I2c.h I2c_PBcfg.c I2c_Regs.h MCU_Config.h Platform_Types.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h Std_Types.h Sw_Delay.c Sw_Delay.h Uart.c Uart.h Uart_Cfg.h Uart_PBcfg.c Uart_Regs.h
