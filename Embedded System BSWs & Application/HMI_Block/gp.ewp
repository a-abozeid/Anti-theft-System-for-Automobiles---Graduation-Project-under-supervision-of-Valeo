# IAR project gp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Common_Macros.h Compiler.h Det.c Det.h Dio.c Dio.h Dio_Cfg.h Dio_PBcfg.c Dio_Regs.h HMI_ECU.c HMI_ECU.h keypad.c keypad.h lcd.c lcd.h lcd_cfg.h MCU_Config.h Platform_Types.h Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h RFID.c RFID.h Spi.c Spi.h Spi_Cfg.h Spi_PBcfg.c Spi_Regs.h Std_Types.h Sw_Delay.c Sw_Delay.h Uart.c Uart.h Uart_Cfg.h Uart_PBcfg.c Uart_Regs.h
